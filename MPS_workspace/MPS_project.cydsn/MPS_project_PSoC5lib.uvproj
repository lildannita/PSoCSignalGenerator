# Keil uVision project MPS_project_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5588AXI-060ES1 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(80000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: MPS_project_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LCD_I2C.c LCD_I2C.h LCD_I2C_BOOT.c LCD_I2C_INT.c LCD_I2C_PM.c LCD_I2C_SLAVE.c LCD_I2C_MASTER.c LCD_I2C_PVT.h lcd_sda_aliases.h lcd_sda.c lcd_sda.h lcd_scl_aliases.h lcd_scl.c lcd_scl.h CapSense_Slider.c CapSense_Slider.h CapSense_Slider_CSHL.c CapSense_Slider_CSHL.h CapSense_Slider_INT.c CapSense_Slider_Pins.c CapSense_Slider_Pins.h CapSense_Slider_PM.c CapSense_Slider_SMS_Wrapper.c CapSense_Slider_TunerHelper.c CapSense_Slider_TunerHelper.h Clock_Button.c Clock_Button.h Back_ISR.c Back_ISR.h Back_Pin_aliases.h Back_Pin.c Back_Pin.h Ok_ISR.c Ok_ISR.h Ok_Pin_aliases.h Ok_Pin.c Ok_Pin.h CapSense_Slider_CompCH0.c CapSense_Slider_CompCH0.h CapSense_Slider_CompCH0_PM.c CapSense_Slider_IdacCH0.c CapSense_Slider_IdacCH0.h CapSense_Slider_IdacCH0_PM.c CapSense_Slider_AMuxCH0.c CapSense_Slider_AMuxCH0.h CapSense_Slider_IntClock.c CapSense_Slider_IntClock.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h PWM_1.c PWM_1.h PWM_1_PM.c PWM_4.c PWM_4.h PWM_4_PM.c PWM_3.c PWM_3.h PWM_3_PM.c PWM_2.c PWM_2.h PWM_2_PM.c PWM_Clock.c PWM_Clock.h BLE_UART.c BLE_UART.h BLE_UART_PM.c BLE_UART_INT.c BLE_UART_BOOT.c BLE_UART_IntClock.c BLE_UART_IntClock.h BLE_ISR.c BLE_ISR.h PWM2_Output_aliases.h PWM2_Output.c PWM2_Output.h PWM1_Output_aliases.h PWM1_Output.c PWM1_Output.h PWM3_Output_aliases.h PWM3_Output.c PWM3_Output.h PWM4_Output_aliases.h PWM4_Output.c PWM4_Output.h DMA_dma.c DMA_dma.h VDAC.c VDAC.h VDAC_PM.c BLE_ISR_CLOSING.c BLE_ISR_CLOSING.h Sine_Output_aliases.h Sine_Output.c Sine_Output.h Sine_Clock.c Sine_Clock.h
target Release (ARM-GNU)
  device: CY8C5588AXI-060ES1 Cypress
  cpu: as above
  output: MPS_project_PSoC5lib (library)
